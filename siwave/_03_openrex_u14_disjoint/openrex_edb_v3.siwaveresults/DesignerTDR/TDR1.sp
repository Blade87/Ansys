* Netlist generated by SIwave - TDR wizard
* SIwave Project: openrex_edb_v3

.model ModelTS S TSTONEFILE="C:/Users/SGI-U3/Documents/GitHub/Ansys/siwave/_03_openrex_u14_disjoint/openrex_edb_v3.siwaveresults/DesignerTDR/TDR1.s20p" INTERPOLATION=LINEAR INTDATTYP=MA HIGHPASS=10 LOWPASS=10 convolution=0 enforce_passivity=0 Noisemodel=External
S1 DRAM_D0_AD2_PBGA624_U1 DRAM_D0_E3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_D1_AE2_PBGA624_U1 DRAM_D1_H3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_D2_AC4_PBGA624_U1 DRAM_D2_H7_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_D3_AA5_PBGA624_U1 DRAM_D3_F8_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_D4_AC1_PBGA624_U1 DRAM_D4_F2_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_D5_AD1_PBGA624_U1 DRAM_D5_G2_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_D6_AB4_PBGA624_U1 DRAM_D6_F7_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_D7_AE4_PBGA624_U1 DRAM_D7_H8_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_DQS0_N_AD3_PBGA624_U1 DRAM_DQS0_N_G3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_DQS0_P_AE3_PBGA624_U1 DRAM_DQS0_P_F3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 FQMODEL="ModelTS"
ADRAM_D0_AD2_PBGA624_U1 DRAM_D0_AD2_PBGA624_U1 COMPONENT=TDR_Single_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=50ohms TIME_DELAY=0.5ns
ADRAM_D1_AE2_PBGA624_U1 DRAM_D1_AE2_PBGA624_U1 COMPONENT=TDR_Single_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=50ohms TIME_DELAY=0.5ns
ADRAM_D2_AC4_PBGA624_U1 DRAM_D2_AC4_PBGA624_U1 COMPONENT=TDR_Single_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=50ohms TIME_DELAY=0.5ns
ADRAM_D3_AA5_PBGA624_U1 DRAM_D3_AA5_PBGA624_U1 COMPONENT=TDR_Single_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=50ohms TIME_DELAY=0.5ns
ADRAM_D4_AC1_PBGA624_U1 DRAM_D4_AC1_PBGA624_U1 COMPONENT=TDR_Single_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=50ohms TIME_DELAY=0.5ns
ADRAM_D5_AD1_PBGA624_U1 DRAM_D5_AD1_PBGA624_U1 COMPONENT=TDR_Single_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=50ohms TIME_DELAY=0.5ns
ADRAM_D6_AB4_PBGA624_U1 DRAM_D6_AB4_PBGA624_U1 COMPONENT=TDR_Single_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=50ohms TIME_DELAY=0.5ns
ADRAM_D7_AE4_PBGA624_U1 DRAM_D7_AE4_PBGA624_U1 COMPONENT=TDR_Single_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=50ohms TIME_DELAY=0.5ns
ADRAM_DQS0_P_AE3_PBGA624_U1 DRAM_DQS0_P_AE3_PBGA624_U1 DRAM_DQS0_N_AD3_PBGA624_U1 COMPONENT=TDR_Differential_Ended RISE_TIME=35ps PULSE_WIDTH=10us PULSE_REPETITION=20us Z0=100ohms TIME_DELAY=0.5ns
R1 DRAM_D0_E3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 0 50ohms
R2 DRAM_D1_H3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 0 50ohms
R3 DRAM_D2_H7_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 0 50ohms
R4 DRAM_D3_F8_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 0 50ohms
R5 DRAM_D4_F2_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 0 50ohms
R6 DRAM_D5_G2_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 0 50ohms
R7 DRAM_D6_F7_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 0 50ohms
R8 DRAM_D7_H8_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 0 50ohms
R9 DRAM_DQS0_P_F3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 DRAM_DQS0_N_G3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2 100ohms
.option num_threads=6
.TRAN 1E-10 5E-09
.print TRAN V(DRAM_D0_AD2_PBGA624_U1) V(DRAM_D1_AE2_PBGA624_U1) V(DRAM_D2_AC4_PBGA624_U1) V(DRAM_D3_AA5_PBGA624_U1) V(DRAM_D4_AC1_PBGA624_U1) V(DRAM_D5_AD1_PBGA624_U1) V(DRAM_D6_AB4_PBGA624_U1) V(DRAM_D7_AE4_PBGA624_U1) V(DRAM_DQS0_P_AE3_PBGA624_U1) V(DRAM_DQS0_N_AD3_PBGA624_U1) V(DRAM_D0_E3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_D1_H3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_D2_H7_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_D3_F8_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_D4_F2_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_D5_G2_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_D6_F7_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_D7_H8_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_DQS0_P_F3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) V(DRAM_DQS0_N_G3_96_FPGA_DD3_14MMX10MM-SMALL_SIZE_U2) O(ADRAM_D0_AD2_PBGA624_U1,zl) O(ADRAM_D1_AE2_PBGA624_U1,zl) O(ADRAM_D2_AC4_PBGA624_U1,zl) O(ADRAM_D3_AA5_PBGA624_U1,zl) O(ADRAM_D4_AC1_PBGA624_U1,zl) O(ADRAM_D5_AD1_PBGA624_U1,zl) O(ADRAM_D6_AB4_PBGA624_U1,zl) O(ADRAM_D7_AE4_PBGA624_U1,zl) O(ADRAM_DQS0_P_AE3_PBGA624_U1,zdiff)
